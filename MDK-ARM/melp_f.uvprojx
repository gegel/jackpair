# Keil uVision project melp_f.uvprojx, settings and files
target melp_f (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: melp_f
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx
  c misc: --C99
  c include: ../Inc;                                  ../Drivers/STM32F4xx_HAL_Driver/Inc;                                  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                  ../Drivers/CMSIS/Include;                                  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dac.c stm32f4xx_hal.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../Src/: stm32f4xx_it.c main.c stm32f4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group mlpe
    ../Src/melpe_old/: classify.c coeff.c dsp_sub.c fec_code.c fft_lib.c fs_lib.c fsvq_cb.c global.c harm.c lpc_lib.c mat_lib.c math_lib.c mathdp31.c mathhalf.c melp_ana.c melp_chn.c melp_sub.c melp_syn.c melpe.c msvq_cb.c npp.c pit_lib.c pitch.c postfilt.c qnt12.c qnt12_cb.c vq_lib.c
  group crp
    ../Src/crp/: cntr.c crc32.c golay23.c shake.c KeccakP-800-u1-armv6m-le-armcc.s
  group mdm
    ../Src/mdm/: plsmdm.c pskmdm.c
  group ecc
    ../Src/ecc/: fe25519_elligator2_isrt.c fe25519_invert.c fe25519_pow2523.c cortex_m4_add.s cortex_m4_mpy121666_add.s cortex_m4_mul.s cortex_m4_sqrt.s cortex_m4_sub.s scalarmult.c
software components: CMSIS:CORE 4.1.0
